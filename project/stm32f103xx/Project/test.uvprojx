# Keil uVision project test.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: boot +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\Include;..\User;..\..\..\lib;..\..\..\component\cmd;..\..\..\component\param;..\..\..\component\soft_timer;..\..\..\component\ymodem;..\User\port
  memory RVCT4: ROM 0x8002000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Libraries/CMSIS/: startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_hd.s
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c
  group CMSIS
    ../User/: system_stm32f10x.c
  group lib
    ../../../lib/: lib_rng.c
  group port
    ../User/port/: delay.c uart.c flash.c hrt.c
  group param
    ../../../component/param/: param.c param_port.c
  group softTimer
    ../../../component/soft_timer/: soft_timer.c
  group cmd
    ../../../component/cmd/: cmd.c cmd_core.c cmd_regist.c
  group cmds
    ../../../component/cmd/cmds/: cmd_clean.c cmd_example.c cmd_help.c cmd_param.c cmd_reboot.c cmd_soft_timer.c
  group user
    ../User/: main.c
